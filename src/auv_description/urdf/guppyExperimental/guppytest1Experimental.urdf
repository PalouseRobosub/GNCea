Commit message: fix: modify vectoring plugin

File: src/auv_description/urdf/guppyExperimental/guppytest1Experimental.urdf (robot description, URDF)
Before this commit: robot guppytest1, 10 links, 9 joints
Joints:
- joint imu_joint: origin xyz=0 0 0.05 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
